#include <string.h>

#include "seal_wrap.h"
#include "secrets.h"      /* generated: S2S2_AUTH_KEY_BYTES, S2S2_AUTH_KEY_FPR */

#if AUTH_ENABLE   /* AUTH=F: this file is not even linked, see the Makefile */

/* ---- shared key (16 bytes): random, generated by `make configure` into generated/secrets.h (not in git) ---- */
static const uint8_t s_sealKey[16] __attribute__((aligned(4))) = S2S2_AUTH_KEY_BYTES;

static uint32_t s_sealTxCounter = 1;
static uint32_t s_sealRxFloor = 0;

static uint64_t sealTag(const uint8_t key[16], const uint8_t *data, uint32_t len)
{
    uint32_t o[2];
    seal_tag(key, data, len, (uint8_t *)o);
    return ((uint64_t)o[1] << 32) | o[0];
}

/* work buffer: payload + counter + tag; word aligned because seal_tag reads words */
static uint8_t s_sealBuf[SEAL_MAX_PAYLOAD + SEAL_AUTH_TRAILER + 4] __attribute__((aligned(4)));

uint16_t Seal_Wrap(const uint8_t *payload, uint16_t len, uint8_t *out)
{
    if (payload == NULL || out == NULL || len == 0 || len > SEAL_MAX_PAYLOAD) return 0;

    uint32_t c = s_sealTxCounter;
    memcpy(s_sealBuf, payload, len);
    s_sealBuf[len]     = (uint8_t)(c >> 24);
    s_sealBuf[len + 1] = (uint8_t)(c >> 16);
    s_sealBuf[len + 2] = (uint8_t)(c >> 8);
    s_sealBuf[len + 3] = (uint8_t)(c);
    uint64_t tag = sealTag(s_sealKey, s_sealBuf, (uint32_t)len + 4U);
    for (uint32_t i = 0; i < SEAL_TAG_LEN; i++)
        s_sealBuf[len + 4U + i] = (uint8_t)(tag >> (8U * i));
    s_sealTxCounter++;

    memcpy(out, s_sealBuf, (size_t)len + SEAL_AUTH_TRAILER);
    return (uint16_t)(len + SEAL_AUTH_TRAILER);
}

/* Forget the receive replay floor (bench / ground test: the sender's counter restarted). */
void Seal_ResetRxFloor(void)
{
    s_sealRxFloor = 0;
}

bool Seal_Unwrap(const uint8_t *wire, uint16_t wireLen,
                 uint8_t *payloadOut, uint16_t payloadOutMax, uint16_t *payloadLenOut)
{
    if (wire == NULL || payloadOut == NULL || payloadLenOut == NULL) return false;
    if (wireLen <= SEAL_AUTH_TRAILER || wireLen > SEAL_MAX_PAYLOAD + SEAL_AUTH_TRAILER) return false;

    uint16_t plen = (uint16_t)(wireLen - SEAL_AUTH_TRAILER);
    if (plen > payloadOutMax) return false;

    memcpy(s_sealBuf, wire, wireLen);
    uint64_t expect = sealTag(s_sealKey, s_sealBuf, (uint32_t)plen + 4U);
    uint8_t diff = 0;
    for (uint32_t i = 0; i < SEAL_TAG_LEN; i++)
        diff |= (uint8_t)(s_sealBuf[plen + 4U + i] ^ (uint8_t)(expect >> (8U * i)));
    if (diff != 0) return false;

    uint32_t counter = ((uint32_t)s_sealBuf[plen] << 24) | ((uint32_t)s_sealBuf[plen + 1] << 16) |
                       ((uint32_t)s_sealBuf[plen + 2] << 8) | (uint32_t)s_sealBuf[plen + 3];
    if (counter <= s_sealRxFloor) return false;
    s_sealRxFloor = counter;

    memcpy(payloadOut, s_sealBuf, plen);
    *payloadLenOut = plen;
    return true;
}

/* 0xA5A50001 = pass, 0xDEAD0000 = fail, 0 = not run (readable with a debugger) */
volatile uint32_t g_sealSelfTest = 0;

static bool sealSelfTestRun(void)
{
    /* tag function against the official SipHash-2-4 vector (key 00..0f, msg 00..0e) */
    static uint8_t kKey[16] __attribute__((aligned(4))), kMsg[16] __attribute__((aligned(4)));
    for (uint32_t i = 0; i < 16; i++) kKey[i] = (uint8_t)i;
    for (uint32_t i = 0; i < 15; i++) kMsg[i] = (uint8_t)i;
    if (sealTag(kKey, kMsg, 15) != 0xa129ca6149be45e5ULL) return false;

    /* wrap -> unwrap round trip, tamper and replay rejection */
    static const uint8_t cmd[13] = { 0x53, 0x04, 0xCC, 0x5E, 0xBD, 0, 0, 0, 0, 0, 0, 0, 0 };
    static uint8_t wire[SEAL_MAX_PAYLOAD + SEAL_AUTH_TRAILER], bad[SEAL_MAX_PAYLOAD + SEAL_AUTH_TRAILER], outp[SEAL_MAX_PAYLOAD];
    uint16_t olen = 0;
    uint16_t w = Seal_Wrap(cmd, sizeof(cmd), wire);
    if (w != sizeof(cmd) + SEAL_AUTH_TRAILER) return false;
    memcpy(bad, wire, w);
    bad[2] ^= 0x01;                                                                /* one flipped bit must fail */
    if (Seal_Unwrap(bad, w, outp, sizeof(outp), &olen)) return false;
    if (!Seal_Unwrap(wire, w, outp, sizeof(outp), &olen)) return false;
    if (olen != sizeof(cmd) || memcmp(outp, cmd, sizeof(cmd)) != 0) return false;
    if (Seal_Unwrap(wire, w, outp, sizeof(outp), &olen)) return false;             /* replay must fail */
    s_sealTxCounter = 1;                                                           /* leave counters fresh */
    s_sealRxFloor = 0;
    return true;
}

bool Seal_SelfTest(void)
{
    bool ok = sealSelfTestRun();
    g_sealSelfTest = ok ? 0xA5A50001UL : 0xDEAD0000UL;
    return ok;
}

#endif /* AUTH_ENABLE */
